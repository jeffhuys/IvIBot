# IAR project lights_stm8_iar.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: c:\osa; c:\osa\example\stm8_iar
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: yyy.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: lights_stm8_iar.c
    ../../: osa.c
    ../../port/stm8/: osa_stm8_iar.s
